# Keil uVision project Blinking_LED.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinking_LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LIBRARIES;.\HAL;.\MCAL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/: Dio_Cfg.h gpio.c gpio.h GPIO_Cfg.c GPIO_Regs.h port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h
    ./: NVIC.c NVIC.h Nvic_Cfg.h Nvic_Cfg.c GPT.c GPT.h GPT__Regs.h GPT_Cfg.h GPT_PBcfg.c
  group LIBRARIES
    ./LIBRARIES/: Common_Macros.h Compiler.h Platform_Types.h Std_Types.h tm4c123gh6pm_registers.h
    ./: Mcu_Hw.h
  group HAL
    ./HAL/: Led.c Led.h
  group APPLICATION
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
